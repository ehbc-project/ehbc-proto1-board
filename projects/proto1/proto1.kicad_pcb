# Repository ehbc-project/ehbc-proto1-board (continued)

## KiCad design projects/proto1/proto1.kicad_pcb (continued)

Schematic: line_in.kicad_sch

Parts:
C53, C60: 47p; C_Disc_D4.3mm_W1.9mm_P5.00mm
C54, C56, C59: 1u; CP_Radial_D5.0mm_P2.50mm
C55, C58: 1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C57: 100n; C_Disc_D4.3mm_W1.9mm_P5.00mm
L4, L5: L; L_Axial_L9.5mm_D4.0mm_P5.08mm_Vertical_Fastron_SMCC
R15, R19: 22k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R16, R18: 47k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R17: 5.1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U28: MC33078; DIP-8_W7.62mm_Socket

Connections:
+5VA: C57.1, U28.8 (V+); also elsewhere on the board
/audio/BLUE_RING: L5.2; also elsewhere on the board
/audio/BLUE_TIP: L4.2; also elsewhere on the board
/audio/LLINE: C55.1; also elsewhere on the board
/audio/RLINE: C58.1; also elsewhere on the board
/audio/VREF: R17.2; also elsewhere on the board
GNDA: C56.2, C57.2, U28.4 (V-); also elsewhere on the board
unnamed: C53.2, C55.2, R15.2, U28.1
unnamed: C54.1, R16.1
unnamed: C54.2, L4.1
unnamed: C58.2, C60.2, R19.2, U28.7
unnamed: C59.1, R18.1
unnamed: C59.2, L5.1
unnamed: C56.1, R17.1, U28.3 (+), U28.5 (+)
unnamed: C53.1, R15.1, R16.2, U28.2 (-)
unnamed: C60.1, R18.2, R19.1, U28.6 (-)

Schematic: line_out.kicad_sch

Parts:
L6, L7: L; L_Axial_L9.5mm_D4.0mm_P5.08mm_Vertical_Fastron_SMCC

Connections:
/audio/LIME_RING: L7.2; also elsewhere on the board
/audio/LIME_TIP: L6.2; also elsewhere on the board

Schematic: mic_in.kicad_sch

Parts:
C44, C52: 1.2n; C_Disc_D4.3mm_W1.9mm_P5.00mm
C45, C51: 10u; CP_Radial_D5.0mm_P2.50mm
C46, C50: 1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C47, C49: 1u; CP_Radial_D5.0mm_P2.50mm
C48: 100n; C_Disc_D4.3mm_W1.9mm_P5.00mm
J13: MS_SEL; PinHeader_1x04_P2.54mm_Vertical
L2, L3: L; L_Axial_L9.5mm_D4.0mm_P5.08mm_Vertical_Fastron_SMCC
R6, R11: 1.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R7, R14: 11k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R8, R10: 47k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R9: 22k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R12, R13: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U27: MC33078; DIP-8_W7.62mm_Socket

Connections:
+5VA: C48.1, R9.1, U27.8 (V+); also elsewhere on the board
/audio/LMIC: C46.1; also elsewhere on the board
/audio/PINK_RING: L3.2; also elsewhere on the board
/audio/PINK_TIP: L2.2; also elsewhere on the board
/audio/RMIC: C50.1; also elsewhere on the board
/audio/VREF: R8.1, R10.2; also elsewhere on the board
GNDA: C45.2, C48.2, C51.2, R12.2, R13.2, U27.4 (V-); also elsewhere on the board
unnamed: C44.2, C46.2, R7.2, U27.1
unnamed: C45.1, R6.1
unnamed: C50.2, C52.2, R14.2, U27.7
unnamed: C51.1, R11.1
unnamed: J13.1, R9.2
unnamed: J13.2, L3.1, R12.1
unnamed: C49.2, J13.3
unnamed: C47.2, J13.4, L2.1, R13.1
unnamed: C47.1, R8.2, U27.3 (+)
unnamed: C44.1, R6.2, R7.1, U27.2 (-)
unnamed: C49.1, R10.1, U27.5 (+)
unnamed: C52.1, R11.2, R14.1, U27.6 (-)

Schematic: ide.kicad_sch

Parts:
J14: IDC_PATA; IDC-Header_2x20_P2.54mm_Vertical

Connections:
/isa/BA1: J14.35 (DA0); also elsewhere on the board
/isa/BA2: J14.33 (DA1); also elsewhere on the board
/isa/BA3: J14.36 (DA2); also elsewhere on the board
/isa/BD0: J14.17 (DD0); also elsewhere on the board
/isa/BD1: J14.15 (DD1); also elsewhere on the board
/isa/BD2: J14.13 (DD2); also elsewhere on the board
/isa/BD3: J14.11 (DD3); also elsewhere on the board
/isa/BD4: J14.9 (DD4); also elsewhere on the board
/isa/BD5: J14.7 (DD5); also elsewhere on the board
/isa/BD6: J14.5 (DD6); also elsewhere on the board
/isa/BD7: J14.3 (DD7); also elsewhere on the board
/isa/BD8: J14.4 (DD8); also elsewhere on the board
/isa/BD9: J14.6 (DD9); also elsewhere on the board
/isa/BD10: J14.8 (DD10); also elsewhere on the board
/isa/BD11: J14.10 (DD11); also elsewhere on the board
/isa/BD12: J14.12 (DD12); also elsewhere on the board
/isa/BD13: J14.14 (DD13); also elsewhere on the board
/isa/BD14: J14.16 (DD14); also elsewhere on the board
/isa/BD15: J14.18 (DD15); also elsewhere on the board
/isa/IOCHRDY: J14.27 (IORDY); also elsewhere on the board
/isa/~IOCS16: J14.32 (IOCS16); also elsewhere on the board
~HDDLED: J14.39 (~LED); also elsewhere on the board
~IDE0_CS: J14.37 (~CS0)
~IDE1_CS: J14.38 (~CS1)
~RD: J14.25 (~DIOR); also elsewhere on the board
~RST: J14.1 (~RST); also elsewhere on the board
~WR: J14.23 (~DIOW); also elsewhere on the board

Schematic: isa_buffer.kicad_sch

Parts:
U30, U33, U34: 74LS573; DIP-20_W7.62mm_Socket
U31, U32: 74LS245; DIP-20_W7.62mm_Socket

Connections:
/isa/BA0: U30.12 (Q7); also elsewhere on the board
/isa/BA1: U30.13 (Q6); also elsewhere on the board
/isa/BA2: U30.14 (Q5); also elsewhere on the board
/isa/BA3: U30.15 (Q4); also elsewhere on the board
/isa/BA4: U30.16 (Q3); also elsewhere on the board
/isa/BA5: U30.17 (Q2); also elsewhere on the board
/isa/BA6: U30.18 (Q1); also elsewhere on the board
/isa/BA7: U30.19 (Q0); also elsewhere on the board
/isa/BA8: U33.12 (Q7); also elsewhere on the board
/isa/BA9: U33.13 (Q6); also elsewhere on the board
/isa/BA10: U33.14 (Q5); also elsewhere on the board
/isa/BA11: U33.15 (Q4); also elsewhere on the board
/isa/BA12: U33.16 (Q3); also elsewhere on the board
/isa/BA13: U33.17 (Q2); also elsewhere on the board
/isa/BA14: U33.18 (Q1); also elsewhere on the board
/isa/BA15: U33.19 (Q0); also elsewhere on the board
/isa/BA16: U34.12 (Q7); also elsewhere on the board
/isa/BA17: U34.13 (Q6); also elsewhere on the board
/isa/BA18: U34.14 (Q5); also elsewhere on the board
/isa/BA19: U34.15 (Q4); also elsewhere on the board
/isa/BA20: U34.16 (Q3); also elsewhere on the board
/isa/BA21: U34.17 (Q2); also elsewhere on the board
/isa/BA22: U34.18 (Q1); also elsewhere on the board
/isa/BA23: U34.19 (Q0); also elsewhere on the board
/isa/BD0: U31.11 (B7); also elsewhere on the board
/isa/BD1: U31.12 (B6); also elsewhere on the board
/isa/BD2: U31.13 (B5); also elsewhere on the board
/isa/BD3: U31.14 (B4); also elsewhere on the board
/isa/BD4: U31.15 (B3); also elsewhere on the board
/isa/BD5: U31.16 (B2); also elsewhere on the board
/isa/BD6: U31.17 (B1); also elsewhere on the board
/isa/BD7: U31.18 (B0); also elsewhere on the board
/isa/BD8: U32.18 (B0); also elsewhere on the board
/isa/BD9: U32.17 (B1); also elsewhere on the board
/isa/BD10: U32.16 (B2); also elsewhere on the board
/isa/BD11: U32.15 (B3); also elsewhere on the board
/isa/BD12: U32.14 (B4); also elsewhere on the board
/isa/BD13: U32.13 (B5); also elsewhere on the board
/isa/BD14: U32.12 (B6); also elsewhere on the board
/isa/BD15: U32.11 (B7); also elsewhere on the board
A0: U30.9 (D7); also elsewhere on the board
A1: U30.8 (D6); also elsewhere on the board
A2: U30.7 (D5); also elsewhere on the board
A3: U30.6 (D4); also elsewhere on the board
A4: U30.5 (D3); also elsewhere on the board
A5: U30.4 (D2); also elsewhere on the board
A6: U30.3 (D1); also elsewhere on the board
A7: U30.2 (D0); also elsewhere on the board
A8: U33.9 (D7); also elsewhere on the board
A9: U33.8 (D6); also elsewhere on the board
A10: U33.7 (D5); also elsewhere on the board
A11: U33.6 (D4); also elsewhere on the board
A12: U33.5 (D3); also elsewhere on the board
A13: U33.4 (D2); also elsewhere on the board
A14: U33.3 (D1); also elsewhere on the board
A15: U33.2 (D0); also elsewhere on the board
A16: U34.9 (D7); also elsewhere on the board
A17: U34.8 (D6); also elsewhere on the board
A18: U34.7 (D5); also elsewhere on the board
A19: U34.6 (D4); also elsewhere on the board
A20: U34.5 (D3); also elsewhere on the board
A21: U34.4 (D2); also elsewhere on the board
A22: U34.3 (D1); also elsewhere on the board
A23: U34.2 (D0); also elsewhere on the board
D16: U31.9 (A7); also elsewhere on the board
D17: U31.8 (A6); also elsewhere on the board
D18: U31.7 (A5); also elsewhere on the board
D19: U31.6 (A4); also elsewhere on the board
D20: U31.5 (A3); also elsewhere on the board
D21: U31.4 (A2); also elsewhere on the board
D22: U31.3 (A1); also elsewhere on the board
D23: U31.2 (A0); also elsewhere on the board
D24: U32.2 (A0); also elsewhere on the board
D25: U32.3 (A1); also elsewhere on the board
D26: U32.4 (A2); also elsewhere on the board
D27: U32.5 (A3); also elsewhere on the board
D28: U32.6 (A4); also elsewhere on the board
D29: U32.7 (A5); also elsewhere on the board
D30: U32.8 (A6); also elsewhere on the board
D31: U32.9 (A7); also elsewhere on the board

Schematic: isa_bus_controller.kicad_sch

Parts:
U29: EPF6016QC240; PQFP-240_32.1x32.1mm_P0.5mm

Connections:
8MHz: U29.103 (IO); also elsewhere on the board
/isa/controller/ALE: U29.106 (IO)
/isa/controller/IOCHRDY: U29.105 (IO)
/isa/controller/SBHE: U29.107 (IO)
/isa/controller/~IOCS16: U29.118 (IO)
/isa/controller/~IOR: U29.112 (IO)
/isa/controller/~IOW: U29.113 (IO)
/isa/controller/~MEMCS16: U29.116 (IO)
/isa/controller/~MEMR: U29.114 (IO)
/isa/controller/~MEMW: U29.115 (IO)
/isa/controller/~NOWS: U29.104 (IO)
/isa/controller/~SMEMR: U29.108 (IO)
/isa/controller/~SMEMW: U29.111 (IO)

Schematic: dramc.kicad_sch

Parts:
U29: EPF6016QC240; PQFP-240_32.1x32.1mm_P0.5mm

Connections:
/dram/dramc/~CAS0: U29.76 (IO)
/dram/dramc/~CAS1: U29.77 (IO)
/dram/dramc/~CAS2: U29.78 (IO)
/dram/dramc/~CAS3: U29.79 (IO)
/dram/dramc/~RAS0: U29.80 (IO)
/dram/dramc/~RAS1: U29.81 (IO)
/dram/dramc/~RAS2: U29.82 (IO)
/dram/dramc/~RAS3: U29.83 (IO)
/dram/dramc/~RAS4: U29.84 (IO)
/dram/dramc/~RAS5: U29.85 (IO)
/dram/dramc/~RAS6: U29.86 (IO)
/dram/dramc/~RAS7: U29.87 (IO)
/dram/dramc/~WE: U29.88 (IO)
MA0: U29.93 (IO); also elsewhere on the board
MA1: U29.94 (IO); also elsewhere on the board
MA2: U29.95 (IO); also elsewhere on the board
MA3: U29.96 (IO); also elsewhere on the board
MA4: U29.97 (IO); also elsewhere on the board
MA5: U29.98 (IO); also elsewhere on the board
MA6: U29.99 (IO); also elsewhere on the board
MA7: U29.100 (IO); also elsewhere on the board
MA8: U29.101 (IO); also elsewhere on the board
MA9: U29.168 (IO); also elsewhere on the board
MA10: U29.173 (IO); also elsewhere on the board
MA11: U29.102 (IO); also elsewhere on the board

Board: 4 copper layers, 174 parts (0 on the bottom side), 393 nets, no tracks yet.
